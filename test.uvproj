# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .h;.\mcu_sdk;.\src
  group mcu_sdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c mcu_api.h protocol.h system.h wifi.h
  group src
    ./src/: codetab.c main.c User_I2C.c User_OLED.c User_SHT30.c User_Timer.c User_Uart.c codetab.h include.h User_I2C.h User_OLED.h User_SHT30.h user_timer.h user_uart.h
